# Keil uVision project VHT_Corstone_SSE-300.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.3.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00100000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 v6Lang=3 wLevel=3
  c define: __ARM_FP=0xe
  c include: ..\VSI\include;..\VSI\sensor\include;..\VSI\sensor\driver\Config
  asm define: __ARM_FP=0xe
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x100000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler
  group App
    ../: app_main.c
  group Board
    ./: main.c retarget_stdio.c
  group Driver
    ../VSI/sensor/driver/: sensor_drv.c
  group Documentation
    ./: README.md
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:SysCounter 1.1.0, Native Driver:SysTimer 1.1.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.1.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
