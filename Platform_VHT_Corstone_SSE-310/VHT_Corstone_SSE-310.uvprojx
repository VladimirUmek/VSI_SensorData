# Keil uVision project VHT_Corstone_SSE-310.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: SSE-310-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.0.0
  cpu: IRAM(0x00000000,0x00008000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00002000) XRAM2(0x20002000,0x00002000) XRAM3(0x20004000,0x00002000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 v6Lang=3 wLevel=3
  c define: __ARM_FP=0xe __FVP_PY STDOUT_CR_LF=1
  c include: ..\VSI\include;..\VSI\sensor\include;..\VSI\sensor\driver\Config
  asm define: __ARM_FP=0xe
  memory RVCT6: RAM 0x20000000 size 0x2000
  memory RVCT7: RAM 0x20002000 size 0x2000
  memory RVCT8: RAM 0x20004000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x8000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-310-MPS3\corstone310_mps3_s.sct
  link misc: --entry=Reset_Handler
  group App
    ../: app_main.c
  group Board
    ./: main.c
  group Board IO
    ./: retarget_stdio.c
  group Driver
    ../VSI/sensor/driver/: sensor_drv.c
  group Documentation
    ./: README.md
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Definition 1.0.0, Device:Startup 1.0.0, Native Driver:SysCounter 1.0.0, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.0.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
